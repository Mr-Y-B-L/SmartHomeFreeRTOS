# Keil uVision project smarthome.uvprojx, settings and files
target smarthome (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smarthome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYS;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\NET\device\inc;..\NET\onenet\inc;..\NET\MQTT;..\NET\CJSON;..\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../HARDWARE/src/: stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/src/: delay.c timer3.c timer4.c control.c led.c oled.c dht11_u8.c key.c beep.c mq2.c fan.c fan_pwm.c mqtt.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c
  group SYS
    ../SYS/: sys.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group OneNET
    ../NET/onenet/src/: base64.c hmac_sha1.c onenet.c
  group net_protocol
    ../NET/MQTT/: MqttKit.c
  group net_device
    ../NET/device/src/: esp8266.c
  group CJSON
    ../NET/CJSON/: cJSON.c
  group usart
    ../usart/: usart.c
